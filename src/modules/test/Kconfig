## src/modules/test/Kconfig
```kconfig
menuconfig MODULES_SAFE_DETECTOR
	bool "safe_detector"
	default n
	---help---
		Enable support for safe_detector
```
